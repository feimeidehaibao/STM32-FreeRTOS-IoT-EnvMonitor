# Keil uVision project 项目.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 项目
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB
  c include: ..\Libraries\Inc;..\APP;..\Libraries\Include;..\User;..\Libraries\Device\ST\STM32F1xx\Include;..\Core\Include;..\module;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\FreeRTOS\Source\portable\MemMang;..\Middlewares\FreeRTOS\Source\portable\RVDS;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../Libraries/Source/Templates/: system_stm32f1xx.c
    ../: startup_stm32f103xb.s
  group HAL
    ../Libraries/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_exti.c
  group USER
    ../User/: adc.c dwt.c main.c usart.c stm32f1xx_hal_msp.c stm32f1xx_it.c gpio.c i2c.c spi.c dma.c stm32f1xx_hal_timebase_tim.c
  group APP
    ../APP/: display.c net.c test.c cunchu.c rtos_task.c
  group module
    ../module/: dht11.c esp8266.c flash.c led.c light.c oled.c
    ../User/: font.c
  group RTOS
    ../Middlewares/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
